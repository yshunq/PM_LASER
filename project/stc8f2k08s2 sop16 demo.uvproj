# Keil uVision project stc8f2k08s2 sop16 demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user;..\common;..\display
  group USER
    ../user/: adc.c MAIN.C pwm.c stc8aid.c timer.c UART.C 24cxx.c
  group MAIN
    ../main/: main_interface.c XS_loading.c XS_advanced_settings.c XS_basic_setting.c XS_set_pulse.c XS_tq_work.c XS_adjust_power.c
  group COMMON
    ../common/: ads7843.c display.c eeprom_data.c other.c
  group display
    ../display/: cut_tq_work.c dis_tq_work.c
